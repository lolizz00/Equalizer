# IAR project usb_terminal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD
  ICCARM.CCIncludePath2: app; board; library\inc; module; $PROJ_DIR$; i2c\; shell\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_terminal.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EMB_FLASH; STM32F10X_MD
  group (top)
    app/: main.c
  group CMSIS
    ./: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group func
    ./: func.c func.h
  group I2C
    i2c/: i2c.c i2c.h utils.c utils.h
  group Other
    app/: includes.h
    ./: write.c
  group Settings
    ./: settings.h
  group shell
    shell/: ring_buffer.c ring_buffer.h sh_exec.c sh_exec.h shell.c shell.h
  group STM32F10xFWLib
    library/src/: stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_tim1.c
  group USB/Class
    app/: cd_class.c usb_desc.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    module/: usb_buffer.c usb_t9.c
    app/: usb_hooks.c
  group USB/HW
    module/: usb_hw.c
  group USB/Init
    ./: usb_init.c usb_init.h
  group Vectors
    app/: stm32f10x_it.c stm32f10x_vector.c
